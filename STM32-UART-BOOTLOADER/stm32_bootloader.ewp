# IAR project stm32_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: APP\; BSP\; IAP\; USER_LIB\; ST\; ST\startup\iar\; ST\FWlib\inc\; ST\CMSIS\; ST\CMSIS\CoreSupport\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_bootloader.bin
  ILINK.IlinkOutputFile: stm32_bootloader.out
  ILINK.IlinkIcfFile: ST\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: app.c cpu.c cpu.h includes.h sys_config.h
    ST/: stm32f10x_it.c
  group BSP
    BSP/: bsp_led_buzzer.c bsp_led_buzzer.h bsp_stmflash.c bsp_stmflash.h bsp_timer.c bsp_timer.h bsp_usart.c bsp_usart.h
  group IAP
    IAP/: iap.c iap.h iap_agreement.c iap_agreement.h
  group ST
    ST/: stm32f10x_flash.icf
  group ST/CMSIS
    ST/CMSIS/CoreSupport/: core_cm3.c
    ST/CMSIS/: system_stm32f10x.c
  group ST/FWlib/inc
    ST/FWlib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group ST/FWlib/src
    ST/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ST/startup
    ST/startup/iar/: startup_stm32f10x_hd.s
  group USER_LIB
    USER_LIB/: cmd_decode.c cmd_decode.h PPfifo.c PPfifo.h vfifo.c vfifo.h
